Commit message: urdf offset

File: atl_viz/models/basic_viz.urdf (robot description, URDF)
Before this commit: robot atl_viz, 3 links, 2 joints
Joints:
- joint joint0: origin xyz=-5 0 0 rpy=0 0 0 -> xyz=0 0 0 rpy=0 0 0
